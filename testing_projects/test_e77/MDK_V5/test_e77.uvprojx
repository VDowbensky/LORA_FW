# Keil uVision project test_e77.uvprojx, settings and files
target stm32wle5 (6230000::V6.23::ARMCLANG)
  device: STM32WLE5CCUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: test_e77 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,STM32WLE5xx,USE_FULL_LL_DRIVER
  c include: ..\app;..\cli;..\mesh;..\periph;..\radiofunc;..\radiohal;..\radioproc;..\..\radiodriver\sx126x;..\..\stm32wle5\lib\Inc;..\..\stm32wle5\lib\Inc\Legacy;..\..\stm32wle5;..\SSD1306;..\..\micromenu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  group periph
    ../periph/: adc.c delay.c flash.c gpio.c subghz.c uart.c i2c.c encoder.c
  group cli
    ../cli/: command_interpreter.c
  group app
    ../app/: app_cli.c bsp.c main.c retarget.c stm32wlxx_it.c test_packet.c menu.c
  group radiofunc
    ../radiofunc/: radio_func.c
  group radioproc
    ../radioproc/: radio_proc.c sx126x_proc.c
  group sx126x
    ../../radiodriver/sx126x/: lr_fhss_mac.c sx126x.c sx126x_bpsk.c sx126x_driver_version.c sx126x_hal.c sx126x_lr_fhss.c
  group radio_hal
    ../radiohal/: sx126x_interface.c
  group startup
    ../../stm32wle5/: system_stm32wlxx.c startup_stm32wle5xx.s
  group lib
    ../../stm32wle5/lib/Src/: stm32wlxx_ll_adc.c stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c stm32wlxx_ll_spi.c stm32wlxx_ll_tim.c stm32wlxx_ll_usart.c stm32wlxx_ll_utils.c stm32wlxx_ll_i2c.c
  group ssd1306
    ../SSD1306/: gui.c ssd1306.c ssd1306_interface.c
  group micromenu
    ../../micromenu/: MicroMenu.c
  group meshtastic
    ../mesh/: pb_functions.c meshtastic_pb.c meshtastic.c
