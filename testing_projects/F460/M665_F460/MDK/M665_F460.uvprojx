# Keil uVision project M665_F460.uvprojx, settings and files
target M665_F460_Debug (6240000::V6.24::ARMCLANG)
  device: HC32F460JCTA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x0,0x80000) IROM2(0x3000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: M665_F460 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ./common/: system_hc32f460.c
  group source
    ./source/: main.c
  group driver
    ./driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_clk.c hc32_ll_gpio.c hc32_ll_fcg.c hc32_ll_aos.c hc32_ll_cmp.c hc32_ll_interrupts.c hc32f460_ll_interrupts_share.c hc32_ll_adc.c hc32_ll_usart.c hc32_ll_spi.c hc32_ll_rtc.c
target M665_F460_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460JCTA HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: as above
  output: M665_F460 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
