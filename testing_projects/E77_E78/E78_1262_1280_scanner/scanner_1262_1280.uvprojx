# Keil uVision project scanner_1262_1280.uvprojx, settings and files
target asr6601 (6240000::V6.24::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: scanner_1262_1280 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_LORA_USE_TCXO
  c include: .\user;.\radio;.\periph;..\common\chip;..\common\lib\inc;..\common\micromenu;..\common\radiodriver\sx126x;..\common\radiodriver\sx128x;..\common\retargertserial;..\common\SSD1306;..\common\cli
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: app_cli.c bsp.c main.c menu.c tremo_it.c ssd1306_interface.c retarget.c
  group startup
    ../common/chip/: system_tremo.c startup_tremo.s
  group lib
    ../common/lib/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group peripherals
    ./periph/: gpio.c uart.c lorac.c flash.c ustimer.c adc.c i2c.c spi.c beeper.c rtc.c
  group radio
    ../common/radiodriver/sx126x/: sx126x.c
    ../common/radiodriver/sx128x/: sx128x.c
    ./radio/: radio.c sx126x_config.c sx126x_interface.c sx128x_config.c sx128x_interface.c
  group cli
    ../common/cli/: command_interpreter.c
  group SSD1306
    ../common/SSD1306/: gui.c ssd1306.c test.c
  group micromenu
    ../common/micromenu/: MicroMenu.c
