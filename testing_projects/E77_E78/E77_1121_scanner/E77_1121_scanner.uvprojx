# Keil uVision project E77_1121_scanner.uvprojx, settings and files
target stm32wle5cc (6240000::V6.24::ARMCLANG)
  device: STM32WLE5CCUx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: E77test
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,STM32WLE5xx,USE_FULL_LL_DRIVER
  c include: .\user;.\radio;.\periph;..\common\stm32wle5;..\common\cli;..\common\stm32wle5_lib\Inc;..\common\micromenu;..\common\radiodriver\lr112x;..\common\radiodriver\sx126x;..\common\SSD1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  group user
    ./user/: app_cli.c bsp.c main.c retarget.c stm32wlxx_it.c menu.c
  group startup
    ../common/stm32wle5/: system_stm32wlxx.c startup_stm32wle5xx.s
  group lib
    ../common/stm32wle5_lib/Src/: stm32wlxx_ll_adc.c stm32wlxx_ll_exti.c stm32wlxx_ll_gpio.c stm32wlxx_ll_pwr.c stm32wlxx_ll_rcc.c stm32wlxx_ll_spi.c stm32wlxx_ll_tim.c stm32wlxx_ll_usart.c stm32wlxx_ll_utils.c
  group peripherals
    ./periph/: subghz.c uart.c ustimer.c adc.c aux_spi.c delay.c flash.c gpio.c
  group radio
    ./radio/: radio.c lr112x_config.c lr112x_interface.c sx126x_config.c sx126x_interface.c
    ../common/radiodriver/lr112x/: lr112x.c
    ../common/radiodriver/sx126x/: sx126x.c
  group cli
    ../common/cli/: command_interpreter.c
  group SSD1306
    ../common/SSD1306/: gui.c ssd1306.c test.c
    ./user/: ssd1306_interface.c
  group micromenu
    ../common/micromenu/: MicroMenu.c
software components: CMSIS:CORE 5.6.0
