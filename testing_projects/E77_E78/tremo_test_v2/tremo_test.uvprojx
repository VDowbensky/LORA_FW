# Keil uVision project tremo_test.uvprojx, settings and files
target asr6601 (6230000::V6.23::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tremo_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\inc;.\lib\inc;.\chip;.\periph;.\radio;.\cli;.\AES;.\SSD1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./src/: main.c bsp.c tremo_it.c retarget.c app_cli.c
  group startup
    ./chip/: startup_tremo.s system_tremo.c
  group lib
    ./lib/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_wdg.c tremo_uart.c
  group peripherals
    ./periph/: gpio.c uart.c lorac.c flash.c ustimer.c adc.c i2c.c
  group radio
    ./radio/: radio_proc.c sx126x.c sx126x_interface.c sx126x_proc.c
  group cli
    ./cli/: command_interpreter.c
  group SSD1306
    ./SSD1306/: ssd1306.c gui.c test.c ssd1306_interface.c
  group AES
    ./AES/: aes_proc.c aes.c
