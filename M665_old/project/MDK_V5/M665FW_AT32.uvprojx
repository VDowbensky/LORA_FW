# Keil uVision project M665FW_AT32.uvprojx, settings and files
target M665FW_AT32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413CBT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M665FW_AT32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F413CBT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/usbd_drivers/inc;..\app;..\cli;..\radiodriver\sx126x;..\radio;..\radiodriver;..\radiodriver\sx128x;..\radiodriver\lr112x;..\radiodriver\pan30xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f413_wk_config.c at32f413_int.c wk_system.c usb_app.c wk_adc.c wk_debug.c wk_exint.c wk_rtc.c wk_spi.c wk_usart.c wk_usbfs.c wk_wdt.c wk_gpio.c rtc.c
  group firmware
    ../../libraries/drivers/src/: at32f413_crm.c at32f413_tmr.c at32f413_rtc.c at32f413_gpio.c at32f413_i2c.c at32f413_usart.c at32f413_pwc.c at32f413_adc.c at32f413_spi.c at32f413_dma.c at32f413_flash.c at32f413_crc.c at32f413_wwdt.c at32f413_wdt.c at32f413_exint.c at32f413_misc.c at32f413_usb.c at32f413_acc.c at32f413_can.c at32f413_sdio.c at32f413_debug.c at32f413_bpr.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ./: startup_at32f413.s
  group middlewares/usbd_driver
    ../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../src/: cdc_class.c cdc_desc.c
  group cli
    ../cli/: command_interpreter.c
  group app
    ../app/: app_cli.c retarget.c bsp.c flash.c mesh_packet.c
  group radioproc
    ../radio/: radio.c sx126x_config.c sx126x_interface.c sx128x_config.c sx128x_interface.c lr112x_config.c lr112x_interface.c
  group radiodriver
    ../radiodriver/sx126x/: sx126x.c
    ../radiodriver/sx128x/: sx128x.c
    ../radiodriver/lr112x/: lr112x.c
